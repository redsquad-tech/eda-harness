v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
P {n VSS inout 30 570 30 570 VSS}
P {n VBIAS inout 670 30 670 30 VBIAS}
P {n IBIAS inout 670 50 670 50 IBIAS}
E {}
v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
P {n VOUT inout 700 30 700 30 VOUT}
P {n DVDD inout 30 30 30 30 DVDD}
P {n AVDD inout 50 30 50 30 AVDD}
P {n DVSS inout 70 570 70 570 DVSS}
P {n AVSS inout 90 570 90 570 AVSS}
P {n V6 inout 670 30 670 30 V6}
P {n V5 inout 670 50 670 50 V5}
P {n V8 inout 670 70 670 70 V8}
P {n V9 inout 670 90 670 90 V9}
P {n V7 inout 670 110 670 110 V7}
P {n VO1 inout 670 130 670 130 VO1}
P {n V4 inout 670 150 670 150 V4}
P {n V3 inout 670 170 670 170 V3}
P {n V2 inout 670 190 670 190 V2}
P {n V1 inout 670 210 670 210 V1}
P {n V0 inout 670 230 670 230 V0}
P {n VCM inout 670 250 670 250 VCM}
P {n VBIAS inout 670 270 670 270 VBIAS}
I {n x5 240 140 0 0 Universal_R_2R_Block2}
I {n x1 400 140 0 0 Universal_R_2R_Block2}
I {n x2 560 140 0 0 Universal_R_2R_Block2}
I {n x3 240 250 0 0 Universal_R_2R_Block2}
I {n x4 400 250 0 0 Universal_R_2R_Block2}
I {n x9 560 250 0 0 Universal_R_2R_Block2}
I {n x10 240 360 0 0 Universal_R_2R_Block2}
I {n x11 400 360 0 0 Universal_R_2R_Block2}
I {n x12 560 360 0 0 Universal_R_2R_Block2}
I {n x13 240 470 0 0 Universal_R_2R_Block2}
I {n x7 400 470 0 0 Output_OA}
I {n x6 560 470 0 0 x1_x32_OA}
I {n x8 240 580 0 0 x1_x32_OA}
W {n __net0__ 180 80 670 50}
W {n __net0__ 30 30 180 95}
W {n __net0__ 180 95 180 205}
W {n __net0__ 180 205 180 315}
W {n __net0__ 180 315 180 425}
W {n __net0__ 180 425 340 95}
W {n __net0__ 340 95 340 205}
W {n __net0__ 340 205 340 315}
W {n __net0__ 340 315 500 95}
W {n __net0__ 500 95 500 205}
W {n __net0__ 500 205 500 315}
W {n __net0__ 300 155 460 140}
W {n __net0__ 70 570 300 170}
W {n __net0__ 300 170 300 280}
W {n __net0__ 300 280 300 390}
W {n __net0__ 300 390 300 500}
W {n __net0__ 300 500 460 170}
W {n __net0__ 460 170 460 280}
W {n __net0__ 460 280 460 390}
W {n __net0__ 460 390 620 170}
W {n __net0__ 620 170 620 280}
W {n __net0__ 620 280 620 390}
W {n __net0__ 50 30 300 185}
W {n __net0__ 300 185 300 295}
W {n __net0__ 300 295 300 405}
W {n __net0__ 300 405 300 515}
W {n __net0__ 300 515 460 185}
W {n __net0__ 460 185 460 295}
W {n __net0__ 460 295 460 405}
W {n __net0__ 460 405 620 185}
W {n __net0__ 620 185 620 295}
W {n __net0__ 620 295 620 405}
W {n __net0__ 90 570 300 200}
W {n __net0__ 300 200 300 310}
W {n __net0__ 300 310 300 420}
W {n __net0__ 300 420 300 530}
W {n __net0__ 300 530 300 610}
W {n __net0__ 300 610 460 200}
W {n __net0__ 460 200 460 310}
W {n __net0__ 460 310 460 420}
W {n __net0__ 460 420 460 500}
W {n __net0__ 460 500 620 200}
W {n __net0__ 620 200 620 310}
W {n __net0__ 620 310 620 420}
W {n __net0__ 620 420 620 500}
W {n __net0__ 340 80 670 30}
W {n __net0__ 460 155 620 140}
W {n __net0__ 500 80 670 110}
W {n __net0__ 300 250 620 155}
W {n __net0__ 180 190 670 70}
W {n __net0__ 300 265 460 250}
W {n __net0__ 340 190 670 90}
W {n __net0__ 500 190 670 230}
W {n __net0__ 300 360 620 265}
W {n __net0__ 180 300 670 210}
W {n __net0__ 300 375 460 360}
W {n __net0__ 340 300 670 190}
W {n __net0__ 460 375 620 360}
W {n __net0__ 500 300 670 170}
W {n __net0__ 300 470 620 375}
W {n __net0__ 180 410 670 150}
W {n __net0__ 340 440 700 30}
W {n __net0__ 300 580 460 470}
W {n __net0__ 460 470 620 470}
W {n __net0__ 620 470 670 250}
W {n __net0__ 300 595 460 485}
W {n __net0__ 460 485 620 485}
W {n __net0__ 620 485 670 270}
E {}
v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 800 4280 0 0 {name=p1 lab=V6}
C {devices/iopin.sym} 800 4320 0 0 {name=p2 lab=V5}
C {devices/iopin.sym} 800 4360 0 0 {name=p3 lab=V8}
C {devices/iopin.sym} 800 4400 0 0 {name=p4 lab=V9}
C {devices/iopin.sym} 800 4440 0 0 {name=p5 lab=V7}
C {devices/iopin.sym} 800 4480 0 0 {name=p6 lab=VO1}
C {devices/iopin.sym} 120 40 1 0 {name=p7 lab=DVDD}
C {devices/iopin.sym} 180 40 1 0 {name=p8 lab=AVDD}
C {devices/iopin.sym} 800 4520 0 0 {name=p9 lab=VOUT}
C {devices/iopin.sym} 800 4560 0 0 {name=p10 lab=V4}
C {devices/iopin.sym} 800 4600 0 0 {name=p11 lab=V3}
C {devices/iopin.sym} 800 4640 0 0 {name=p12 lab=V2}
C {devices/iopin.sym} 800 4680 0 0 {name=p13 lab=V1}
C {devices/iopin.sym} 800 4720 0 0 {name=p14 lab=V0}
C {devices/iopin.sym} 800 4760 0 0 {name=p15 lab=VCM}
C {devices/iopin.sym} 120 9140 3 0 {name=p16 lab=DVSS}
C {devices/iopin.sym} 180 9140 3 0 {name=p17 lab=AVSS}
C {devices/iopin.sym} 800 4800 0 0 {name=p18 lab=VBIAS}
C {spice_v.sym} 440 5760 0 0 {name=VI4 value=0}
C {spice_v.sym} 200 7460 0 0 {name=VI6 value=0}
C {spice_v.sym} 200 7660 0 0 {name=VI7 value=0}
C {spice_v.sym} 200 3860 0 0 {name=VI11 value=0}
C {spice_v.sym} 200 5260 0 0 {name=VI2 value=0}
C {spice_v.sym} 200 3460 0 0 {name=VI1 value=0}
C {spice_v.sym} 200 7060 0 0 {name=VI3 value=0}
C {spice_v.sym} 200 1260 0 0 {name=VICM1 value=0}
C {spice_v.sym} 200 8260 0 0 {name=VICM2 value=0}
C {spice_v.sym} 200 7260 0 0 {name=VI5 value=0}
C {spice_v.sym} 200 7860 0 0 {name=VI8 value=0}
C {spice_v.sym} 200 8060 0 0 {name=VI9 value=0}
C {spice_v.sym} 200 3660 0 0 {name=VI10 value=0}
C {spice_v.sym} 200 4060 0 0 {name=VI12 value=0}
C {spice_v.sym} 200 4260 0 0 {name=VI14 value=0}
C {spice_v.sym} 200 8860 0 0 {name=VINN2 value=0}
C {Universal_R_2R_Block2.sym} 440 4960 0 0 {name=x5}
C {Universal_R_2R_Block2.sym} 440 3360 0 0 {name=x1}
C {Universal_R_2R_Block2.sym} 440 4360 0 0 {name=x2}
C {Universal_R_2R_Block2.sym} 440 4560 0 0 {name=x3}
C {Universal_R_2R_Block2.sym} 440 4760 0 0 {name=x4}
C {spice_v.sym} 440 5360 0 0 {name=VI15 value=0}
C {spice_v.sym} 200 4460 0 0 {name=VI16 value=0}
C {spice_v.sym} 440 5560 0 0 {name=VI22 value=0}
C {spice_v.sym} 200 1660 0 0 {name=VICM3 value=0}
C {spice_v.sym} 200 4660 0 0 {name=VI17 value=0}
C {spice_v.sym} 200 4860 0 0 {name=VI18 value=0}
C {spice_v.sym} 200 5060 0 0 {name=VI19 value=0}
C {spice_v.sym} 200 5460 0 0 {name=VI20 value=0}
C {spice_v.sym} 200 1460 0 0 {name=VICM21 value=0}
C {spice_v.sym} 200 8460 0 0 {name=VICM22 value=0}
C {spice_v.sym} 200 5660 0 0 {name=VI23 value=0}
C {spice_v.sym} 200 5860 0 0 {name=VI24 value=0}
C {spice_v.sym} 200 6060 0 0 {name=VI25 value=0}
C {spice_v.sym} 200 6260 0 0 {name=VI26 value=0}
C {spice_v.sym} 200 6460 0 0 {name=VI27 value=0}
C {spice_v.sym} 200 6660 0 0 {name=VI28 value=0}
C {Universal_R_2R_Block2.sym} 440 5160 0 0 {name=x9}
C {Universal_R_2R_Block2.sym} 440 3560 0 0 {name=x10}
C {Universal_R_2R_Block2.sym} 440 3760 0 0 {name=x11}
C {Universal_R_2R_Block2.sym} 440 3960 0 0 {name=x12}
C {Universal_R_2R_Block2.sym} 440 4160 0 0 {name=x13}
C {spice_v.sym} 200 6860 0 0 {name=VI29 value=0}
C {spice_v.sym} 200 8660 0 0 {name=VINN1 value=0}
C {Output_OA.sym} 200 260 0 0 {name=x7}
C {x1_x32_OA.sym} 200 460 0 0 {name=x6}
C {x1_x32_OA.sym} 200 660 0 0 {name=x8}
C {sky130_fd_pr__res_xhigh_po_0p35.sym} 200 860 0 0 {name=XR11 L=20 mult=1 m=1}
C {sky130_fd_pr__res_xhigh_po_0p35.sym} 200 2060 0 0 {name=XR12 L=640 mult=1 m=1}
C {sky130_fd_pr__res_xhigh_po_0p35.sym} 200 1060 0 0 {name=XR2 L=40 mult=1 m=1}
C {sky130_fd_pr__res_xhigh_po_0p35.sym} 200 2460 0 0 {name=XR4 L=40 mult=1 m=1}
C {sky130_fd_pr__res_xhigh_po_0p35.sym} 200 3260 0 0 {name=XR9 L=1280 mult=1 m=1}
C {sky130_fd_pr__res_xhigh_po_0p35.sym} 200 2660 0 0 {name=XR5 L=1280 mult=1 m=1}
C {sky130_fd_pr__res_xhigh_po_0p35.sym} 200 2860 0 0 {name=XR6 L=20 mult=1 m=1}
C {sky130_fd_pr__res_xhigh_po_0p35.sym} 200 1860 0 0 {name=XR1 L=20 mult=1 m=1}
C {sky130_fd_pr__res_xhigh_po_0p35.sym} 200 2260 0 0 {name=XR3 L=20 mult=1 m=1}
C {sky130_fd_pr__res_xhigh_po_0p35.sym} 200 3060 0 0 {name=XR7 L=20 mult=1 m=1}
N 460 40 460 5740 {lab=AVDD}
N 180 40 460 40 {}
N 620 5340 460 5340 {}
N 620 5540 460 5540 {}
N 620 5740 460 5740 {}
N 380 480 380 9140 {lab=AVSS}
N 180 9140 380 9140 {}
N 200 480 380 480 {}
N 200 680 380 680 {}
N 200 880 380 880 {}
N 460 3620 380 3620 {}
N 460 3820 380 3820 {}
N 460 4020 380 4020 {}
N 460 4220 380 4220 {}
N 460 4420 380 4420 {}
N 460 4620 380 4620 {}
N 460 4820 380 4820 {}
N 460 5020 380 5020 {}
N 460 5220 380 5220 {}
N 460 5420 380 5420 {}
N 420 40 420 5140 {lab=DVDD}
N 120 40 420 40 {}
N 420 3620 420 9140 {lab=DVSS}
N 120 9140 420 9140 {}
N 620 5080 720 5080 {lab=V0}
N 720 5080 720 4720 {}
N 720 4720 800 4720 {}
N 620 3480 720 3480 {lab=V1}
N 720 3480 720 4680 {}
N 720 4680 800 4680 {}
N 620 3680 720 3680 {lab=V2}
N 720 3680 720 4640 {}
N 720 4640 800 4640 {}
N 620 3880 720 3880 {lab=V3}
N 720 3880 720 4600 {}
N 720 4600 800 4600 {}
N 620 4080 720 4080 {lab=V4}
N 720 4080 720 4560 {}
N 720 4560 800 4560 {}
N 620 4880 720 4880 {lab=V5}
N 720 4880 720 4320 {}
N 720 4320 800 4320 {}
N 620 3280 720 3280 {lab=V6}
N 720 3280 720 4280 {}
N 720 4280 800 4280 {}
N 620 4280 720 4280 {lab=V7}
N 720 4280 720 4440 {}
N 720 4440 800 4440 {}
N 620 4480 720 4480 {lab=V8}
N 720 4480 720 4360 {}
N 720 4360 800 4360 {}
N 620 4680 720 4680 {lab=V9}
N 720 4680 720 4400 {}
N 720 4400 800 4400 {}
N 380 320 380 4800 {lab=VBIAS}
N 800 4800 380 4800 {}
N 380 280 380 4760 {lab=VCM}
N 800 4760 380 4760 {}
N 380 860 380 4480 {lab=VO1}
N 800 4480 380 4480 {}
N 380 200 380 4520 {lab=VOUT}
N 800 4520 380 4520 {}
N 380 400 380 8840 {lab=Vx1}
N 380 600 380 8640 {lab=Vx32}
N 380 240 380 8480 {lab=net1}
N 380 640 380 2060 {lab=net10}
N 380 1820 380 2860 {lab=net11}
N 380 1440 380 6680 {lab=net12}
N 380 4680 380 8440 {lab=net13}
N 380 1860 500 1860 {lab=net14}
N 500 1860 500 4240 {}
N 500 4240 620 4240 {}
N 380 6840 380 8680 {lab=net15}
N 620 3600 620 5240 {lab=net16}
N 620 3640 620 3800 {lab=net17}
N 620 3840 620 4000 {lab=net18}
N 620 4040 620 4200 {lab=net19}
N 380 1680 380 2620 {lab=net2}
N 620 4640 620 4800 {lab=net20}
N 620 4440 620 4600 {lab=net21}
N 620 3440 620 4400 {lab=net22}
N 620 3400 620 5040 {lab=net23}
N 380 3260 380 7680 {lab=net24}
N 200 240 400 240 {lab=net25}
N 400 240 400 5780 {}
N 400 5780 620 5780 {}
N 380 3840 500 3840 {lab=net26}
N 500 3840 500 4720 {}
N 500 4720 620 4720 {}
N 380 5240 500 5240 {lab=net27}
N 500 5240 500 4760 {}
N 500 4760 620 4760 {}
N 380 3440 500 3440 {lab=net28}
N 500 3440 500 4520 {}
N 500 4520 620 4520 {}
N 380 7040 500 7040 {lab=net29}
N 500 7040 500 4560 {}
N 500 4560 620 4560 {}
N 380 2660 380 7480 {lab=net3}
N 380 7240 500 7240 {lab=net30}
N 500 7240 500 4320 {}
N 500 4320 620 4320 {}
N 380 7840 500 7840 {lab=net31}
N 500 7840 500 4360 {}
N 500 4360 620 4360 {}
N 380 8040 500 8040 {lab=net32}
N 500 8040 500 3320 {}
N 500 3320 620 3320 {}
N 380 3640 500 3640 {lab=net33}
N 500 3640 500 3360 {}
N 500 3360 620 3360 {}
N 380 4040 500 4040 {lab=net34}
N 500 4040 500 4920 {}
N 500 4920 620 4920 {}
N 380 4240 500 4240 {lab=net35}
N 500 4240 500 4960 {}
N 500 4960 620 4960 {}
N 380 4480 500 4480 {lab=net36}
N 500 4480 500 5000 {}
N 500 5000 620 5000 {}
N 200 440 400 440 {lab=net37}
N 400 440 400 5380 {}
N 400 5380 620 5380 {}
N 200 640 400 640 {lab=net38}
N 400 640 400 5580 {}
N 400 5580 620 5580 {}
N 380 4640 500 4640 {lab=net39}
N 500 4640 500 4120 {}
N 500 4120 620 4120 {}
N 380 2220 380 3060 {lab=net4}
N 380 4840 500 4840 {lab=net40}
N 500 4840 500 4160 {}
N 500 4160 620 4160 {}
N 380 5040 500 5040 {lab=net41}
N 500 5040 500 3920 {}
N 500 3920 620 3920 {}
N 380 5440 500 5440 {lab=net42}
N 500 5440 500 3960 {}
N 500 3960 620 3960 {}
N 380 5640 500 5640 {lab=net43}
N 500 5640 500 3720 {}
N 500 3720 620 3720 {}
N 380 5840 500 5840 {lab=net44}
N 500 5840 500 3760 {}
N 500 3760 620 3760 {}
N 380 6040 500 6040 {lab=net45}
N 500 6040 500 3520 {}
N 500 3520 620 3520 {}
N 380 6240 500 6240 {lab=net46}
N 500 6240 500 3560 {}
N 500 3560 620 3560 {}
N 380 6440 500 6440 {lab=net47}
N 500 6440 500 5120 {}
N 500 5120 620 5120 {}
N 380 6640 500 6640 {lab=net48}
N 500 6640 500 5160 {}
N 500 5160 620 5160 {}
N 380 6880 500 6880 {lab=net49}
N 500 6880 500 5200 {}
N 500 5200 620 5200 {}
N 380 1240 380 7880 {lab=net5}
N 380 3480 380 8240 {lab=net6}
N 380 2260 500 2260 {lab=net7}
N 500 2260 500 4840 {}
N 500 4840 620 4840 {}
N 380 4440 380 8880 {lab=net8}
N 380 440 380 2460 {lab=net9}

v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
P {n VINP inout 30 30 30 30 VINP}
P {n VINN inout 30 50 30 50 VINN}
P {n VOUT1 inout 700 30 700 30 VOUT1}
P {n AVDD inout 30 30 30 30 AVDD}
P {n AVSS inout 50 570 50 570 AVSS}
P {n CM inout 670 30 670 30 CM}
P {n VBIAS inout 670 50 670 50 VBIAS}
I {n x1 240 140 0 0 Input_Stage_OA1}
I {n x2 240 250 0 0 Input_Stage_OA1}
I {n x3 240 360 0 0 Input_Stage_OA2}
W {n __net0__ 180 110 180 125}
W {n __net0__ 30 50 300 140}
W {n __net0__ 300 155 300 265}
W {n __net0__ 300 265 300 375}
W {n __net0__ 300 375 670 50}
W {n __net0__ 50 570 300 170}
W {n __net0__ 300 170 300 280}
W {n __net0__ 300 280 300 390}
W {n __net0__ 180 220 180 235}
W {n __net0__ 30 30 300 250}
E {}
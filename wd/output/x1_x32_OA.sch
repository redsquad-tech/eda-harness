v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
P {n VINN inout 30 30 30 30 VINN}
P {n VINP inout 30 50 30 50 VINP}
P {n VOUT inout 700 30 700 30 VOUT}
P {n VDD inout 30 30 30 30 VDD}
P {n VSS inout 50 570 50 570 VSS}
P {n VBIAS inout 670 30 670 30 VBIAS}
E {}
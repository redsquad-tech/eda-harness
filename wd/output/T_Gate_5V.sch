v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
P {n AVDD inout 30 30 30 30 AVDD}
P {n AVSS inout 50 570 50 570 AVSS}
P {n UPPER inout 670 30 670 30 UPPER}
P {n PGATE inout 670 50 670 50 PGATE}
P {n NGATE inout 670 70 670 70 NGATE}
P {n LOWER inout 670 90 670 90 LOWER}
E {}
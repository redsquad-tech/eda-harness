v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
P {n VINN inout 30 30 30 30 VINN}
P {n VINP inout 30 50 30 50 VINP}
P {n VOUT inout 700 30 700 30 VOUT}
P {n AVDD inout 30 30 30 30 AVDD}
P {n DVDD inout 50 30 50 30 DVDD}
P {n AVSS inout 70 570 70 570 AVSS}
P {n DVSS inout 90 570 90 570 DVSS}
P {n V[9] inout 670 30 670 30 V[9]}
P {n V[8] inout 670 50 670 50 V[8]}
P {n V[7] inout 670 70 670 70 V[7]}
P {n V[6] inout 670 90 670 90 V[6]}
P {n V[5] inout 670 110 670 110 V[5]}
P {n V[4] inout 670 130 670 130 V[4]}
P {n V[3] inout 670 150 670 150 V[3]}
P {n V[2] inout 670 170 670 170 V[2]}
P {n V[1] inout 670 190 670 190 V[1]}
P {n V[0] inout 670 210 670 210 V[0]}
P {n VCM inout 670 230 670 230 VCM}
P {n IBIAS inout 670 250 670 250 IBIAS}
I {n x1 240 140 0 0 Parallel_10B_Block2}
I {n x2 240 250 0 0 Input_Stage_v1}
I {n x3 240 360 0 0 vbias_gen_pga}
W {n __net0__ 180 5 670 90}
W {n __net0__ 180 20 670 110}
W {n __net0__ 180 35 670 50}
W {n __net0__ 180 50 670 30}
W {n __net0__ 180 65 670 70}
W {n __net0__ 180 80 180 235}
W {n __net0__ 50 30 180 95}
W {n __net0__ 30 30 180 110}
W {n __net0__ 180 125 700 30}
W {n __net0__ 300 140 670 130}
W {n __net0__ 300 155 670 150}
W {n __net0__ 300 170 670 170}
W {n __net0__ 300 185 670 190}
W {n __net0__ 300 200 670 210}
W {n __net0__ 300 215 300 265}
W {n __net0__ 300 265 670 230}
W {n __net0__ 90 570 300 230}
W {n __net0__ 70 570 300 245}
W {n __net0__ 300 245 300 280}
W {n __net0__ 300 280 300 375}
W {n __net0__ 180 345 300 260}
W {n __net0__ 300 260 300 295}
W {n __net0__ 30 50 180 220}
W {n __net0__ 30 30 300 250}
W {n __net0__ 300 360 670 250}
E {}
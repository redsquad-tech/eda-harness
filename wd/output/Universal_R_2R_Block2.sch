v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
P {n R2RIN inout 30 30 30 30 R2RIN}
P {n VIRTOUT inout 700 30 700 30 VIRTOUT}
P {n CMOUT inout 700 50 700 50 CMOUT}
P {n R2ROUT inout 700 70 700 70 R2ROUT}
P {n DVDD inout 30 30 30 30 DVDD}
P {n AVDD inout 50 30 50 30 AVDD}
P {n DVSS inout 70 570 70 570 DVSS}
P {n AVSS inout 90 570 90 570 AVSS}
P {n VD inout 670 30 670 30 VD}
I {n x12 240 140 0 0 T_Gate_5V}
I {n x13 400 140 0 0 T_Gate_5V}
I {n x1 240 250 0 0 sky130_fd_sc_hvl__lsbuflv2hv_1}
I {n x2 400 250 0 0 sky130_fd_sc_hvl__inv_1}
I {n x3 240 360 0 0 sky130_fd_sc_hvl__diode_2}
W {n __net0__ 180 110 340 125}
W {n __net0__ 340 125 460 280}
W {n __net0__ 180 125 300 295}
W {n __net0__ 300 295 340 110}
W {n __net0__ 340 110 340 205}
W {n __net0__ 300 140 460 140}
W {n __net0__ 90 570 300 155}
W {n __net0__ 300 155 460 155}
W {n __net0__ 50 30 300 170}
W {n __net0__ 300 170 300 265}
W {n __net0__ 300 265 300 280}
W {n __net0__ 300 280 300 375}
W {n __net0__ 300 375 300 390}
W {n __net0__ 300 390 460 170}
W {n __net0__ 460 170 460 250}
W {n __net0__ 460 250 460 265}
W {n __net0__ 180 205 180 330}
W {n __net0__ 180 330 670 30}
W {n __net0__ 30 30 180 220}
W {n __net0__ 70 570 180 235}
W {n __net0__ 180 235 180 345}
W {n __net0__ 180 345 300 250}
W {n __net0__ 300 250 300 360}
W {n __net0__ 300 360 340 220}
W {n __net0__ 340 220 340 235}
E {}